#include "display/font.h"

#include <string.h>

// Column-major, LSB on top: the classic 5x7 glyphs.
static const uint8_t DIGITS[10][FONT_W] = {
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, {0x00, 0x42, 0x7F, 0x40, 0x00}, {0x42, 0x61, 0x51, 0x49, 0x46},
    {0x21, 0x41, 0x45, 0x4B, 0x31}, {0x18, 0x14, 0x12, 0x7F, 0x10}, {0x27, 0x45, 0x45, 0x45, 0x39},
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03}, {0x36, 0x49, 0x49, 0x49, 0x36},
    {0x06, 0x49, 0x49, 0x29, 0x1E},
};

static const uint8_t LETTERS[26][FONT_W] = {
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, {0x7F, 0x49, 0x49, 0x49, 0x36}, {0x3E, 0x41, 0x41, 0x41, 0x22},
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, {0x7F, 0x49, 0x49, 0x49, 0x41}, {0x7F, 0x09, 0x09, 0x09, 0x01},
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, {0x7F, 0x08, 0x08, 0x08, 0x7F}, {0x00, 0x41, 0x7F, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3F, 0x01}, {0x7F, 0x08, 0x14, 0x22, 0x41}, {0x7F, 0x40, 0x40, 0x40, 0x40},
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, {0x7F, 0x04, 0x08, 0x10, 0x7F}, {0x3E, 0x41, 0x41, 0x41, 0x3E},
    {0x7F, 0x09, 0x09, 0x09, 0x06}, {0x3E, 0x41, 0x51, 0x21, 0x5E}, {0x7F, 0x09, 0x19, 0x29, 0x46},
    {0x46, 0x49, 0x49, 0x49, 0x31}, {0x01, 0x01, 0x7F, 0x01, 0x01}, {0x3F, 0x40, 0x40, 0x40, 0x3F},
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, {0x3F, 0x40, 0x38, 0x40, 0x3F}, {0x63, 0x14, 0x08, 0x14, 0x63},
    {0x07, 0x08, 0x70, 0x08, 0x07}, {0x61, 0x51, 0x49, 0x45, 0x43},
};

static const struct {
    char c;
    uint8_t cols[FONT_W];
} PUNCT[] = {
    {'!', {0x00, 0x00, 0x5F, 0x00, 0x00}}, {'.', {0x00, 0x60, 0x60, 0x00, 0x00}},
    {':', {0x00, 0x36, 0x36, 0x00, 0x00}}, {'-', {0x08, 0x08, 0x08, 0x08, 0x08}},
    {'?', {0x02, 0x01, 0x51, 0x09, 0x06}}, {'/', {0x20, 0x10, 0x08, 0x04, 0x02}},
    {'<', {0x08, 0x14, 0x22, 0x41, 0x00}}, {'>', {0x00, 0x41, 0x22, 0x14, 0x08}},
    {'+', {0x08, 0x08, 0x3E, 0x08, 0x08}}, {'\'', {0x00, 0x00, 0x07, 0x00, 0x00}},
    {'=', {0x14, 0x14, 0x14, 0x14, 0x14}}, {'%', {0x23, 0x13, 0x08, 0x64, 0x62}},
};

const uint8_t *font_glyph(char c) {
    static const uint8_t SPACE[FONT_W] = {0};
    if (c >= '0' && c <= '9') return DIGITS[c - '0'];
    if (c >= 'a' && c <= 'z') c = (char)(c - 'a' + 'A');
    if (c >= 'A' && c <= 'Z') return LETTERS[c - 'A'];
    for (size_t i = 0; i < sizeof(PUNCT) / sizeof(PUNCT[0]); i++) {
        if (PUNCT[i].c == c) return PUNCT[i].cols;
    }
    return SPACE;
}

int font_width(const char *s, int scale) {
    const int n = (int)strlen(s);
    return n ? (n * FONT_ADVANCE - 1) * scale : 0;
}

int font_draw(gfx_t *g, int x, int y, const char *s, int scale, gfx_color_t c) {
    const int x0 = x;
    for (; *s; s++, x += FONT_ADVANCE * scale) {
        const uint8_t *cols = font_glyph(*s);
        for (int cx = 0; cx < FONT_W; cx++) {
            for (int cy = 0; cy < FONT_H; cy++) {
                if (cols[cx] & (1u << cy)) gfx_fill_rect(g, x + cx * scale, y + cy * scale, scale, scale, c);
            }
        }
    }
    return x - x0 - scale;
}

void font_draw_centered(gfx_t *g, int cx, int y, const char *s, int scale, gfx_color_t c) {
    font_draw(g, cx - font_width(s, scale) / 2, y, s, scale, c);
}
